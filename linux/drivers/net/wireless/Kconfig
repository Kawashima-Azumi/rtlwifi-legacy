## linux/drivers/net/wireless/Kconfig
```kconfig
source "drivers/net/wireless/realtek/rtl8192cu/Kconfig"
source "drivers/net/wireless/realtek/rtl8821au/Kconfig"
```
